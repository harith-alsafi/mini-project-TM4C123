# Keil uVision project mini-project-TM4C123G.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mini-project-TM4C123G
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: clock.c clock.h flash-storage.c flash-storage.h helpers.c helpers.h keypad.c keypad.h lcd.c lcd.h main.c playground.c ports.c ports.h program-logic.c program-logic.h TExaS.h texas.o unit-test.c unit-test.h user-interface.c user-interface.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
